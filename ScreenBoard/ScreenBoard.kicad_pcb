# Repository KisonHe/HoloCube-PCB

## KiCad design ScreenBoard/ScreenBoard.kicad_pcb

Parts:
C1, C2: 1uf; C_0402_1005Metric
C3, C4, C5: 100nf; C_0402_1005Metric
D1, D2: D; R_0603_1608Metric
J1: Conn_01x12_MountingPin; Hirose_FH12-12S-0.5SH_1x12-1MP_P0.50mm_Horizontal
J2: LCD_FPC_0.7mm_welding; FPC_welding_0.7mm_P0.4mm
Q1: AO3415A; SOT-23
R1: 1k; R_0402_1005Metric
R2: 0; R_0402_1005Metric
R3, R4, R5: 5.1k; C_0402_1005Metric
SW1: C318951
U1: XC6209; SOT-23-5

Connections:
+3V3: D1.2 (A), J1.6, J2.4, R3.2, R4.2, R5.2
+5V: C1.1, J1.5, U1.1 (VIN), U1.3 (CE)
/BTN_Down: C3.1, J1.2, R3.1, SW1.T
/BTN_Left: C4.1, J1.3, R4.1, SW1.2
/BTN_Right: C5.1, J1.4, R5.1, SW1.1
/DC: J1.8, J2.7
/LCD_BL: J1.12, R1.1
/LCD_BL_VCC: D1.1 (K), D2.1 (K), Q1.3 (D)
/LCD_MOSI: J1.10, J2.10
/LCD_SCK: J1.9, J2.9
/LEDA: J2.3, Q1.2 (S)
/RES: J1.11, J2.11
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J1.1, J1.7, J1.MP (MountPin), J2.1, J2.2, J2.5, J2.6, J2.12, R2.1, SW1.C, U1.2 (VSS)
unnamed: C2.1, D2.2 (A), U1.5 (VOUT)
unnamed: J2.8, R2.2
unnamed: Q1.1 (G), R1.2

Notes on the sheet:
封装不对，小了
LDO

Board: 2 copper layers, 25.0 x 30.0 mm, 17 parts (0 on the bottom side), 16 nets.

## KiCad design HoloCube/HoloCube.kicad_pcb

Parts:
AE1: Antenna; Texas_SWRA117D_2.4GHz_Right
C1: 10uf; C_0603_1608Metric
C2, C4: 0.1uf; C_0402_1005Metric
C3, C10: 0.1uF; C_0402_1005Metric; LCSC C1591
C5, C6: 1uf; C_0402_1005Metric
C7, C9: TBD; C_0402_1005Metric; LCSC C1591
C8: 10pf; C_0402_1005Metric; LCSC C1591
D1: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
J1: ESPProgUART_RX; IDC_1.27mm_6P
J2: Conn_01x12_MountingPin; Hirose_FH12-12S-0.5SH_1x12-1MP_P0.50mm_Horizontal
J3: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J4: Micro_SD_Card; C91145
JP1, JP2: Jumper; R_0402_1005Metric
Q1: MMBT3904; SOT-23
R1, R3: 10k; R_0402_1005Metric
R4: 1.5k; R_0402_1005Metric; LCSC C429617
R5, R8: 3.3k; R_0402_1005Metric; LCSC C429617
R6, R7: 5.1k; R_0402_1005Metric; LCSC C325524
R9, R12: 100k; R_0402_1005Metric; LCSC C429617
R10, R14, R15, R16, R17: 10k; R_0402_1005Metric; LCSC C429617
U1: ESP32-PICO-D4; QFN-48-1EP_7x7mm_P0.5mm_EP5.3x5.3mm
U2: LIS2DH12TR; PQFN50P200X200100-12N
U3: BH1750FVI-TR; XDCR_BH1750FVI-TR; PARTREV D
U4: XC6209; SOT-23-5

Connections:
+3V3: C1.1, C2.1, C4.1, C6.1, J1.2 (VDD), J2.7, J4.4 (VDD), JP2.1 (A), R1.1, R3.1, R4.2, R5.1, R8.1, R12.2, R14.1, R15.1, R16.1, R17.1, U1.1 (VDDA), U1.3 (VDDA3P3), U1.4 (VDDA3P3), U1.19 (VDD3P3_RTC), U1.37 (VDD3P3_CPU), U1.43 (VDDA), U1.46 (VDDA), U2.2 (CS), U2.9 (VDD), U2.10 (VDD_IO), U3.1 (VCC), U4.5 (VOUT)
+5V: C5.1, C10.1, D1.1 (VDD), J2.8, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R10.2, U4.1 (VIN), U4.3 (CE)
/BTN_Down: J2.11, U1.42 (IO21)
/BTN_Left: J2.10, U1.17 (IO14)
/BTN_Right: J2.9, U1.16 (IO27)
/DC: J2.5, U1.36 (IO23)
/EN: C3.1, J1.1 (EN), R1.2, U1.9 (EN)
/I2C_SCL: R5.2, U1.13 (IO33), U2.1 (SCL/SPC), U3.6 (SCL)
/I2C_SDA: R8.2, U1.12 (IO32), U2.4 (SDA/SDI/SDO), U3.4 (SDA)
/IO0: J1.6 (IO0), U1.23 (IO0)
/IO4: J2.2, U1.24 (IO4)
/IO5: J2.3, U1.34 (IO5)
/IO13: J4.5 (CLK), R16.2, U1.20 (IO13)
/IO15: J4.7 (DAT0), R14.2, U1.21 (IO15)
/IO18: J2.4, U1.35 (IO18)
/IO19: Q1.2 (E), U1.38 (IO19)
/IO22: J2.1, U1.39 (IO22)
/IO25: J4.3 (CMD), R15.2, U1.14 (IO25)
/IO26: J4.2 (DAT3/CD), R17.2, U1.15 (IO26)
/RX: J1.5 (ESPRXD), U1.40 (U0RXD/IO3)
/TX: J1.3 (ESPTXD), U1.41 (U0TXD/IO1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C9.1, C10.2, D1.3 (VSS), J1.4 (GND), J2.6, J2.12, J2.MP (MountPin), J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), J4.6 (VSS), J4.9 (SHIELD), JP1.1 (A), R6.1, R7.1, R9.2, U1.49 (GND), U2.5 (RES), U2.6 (GND), U2.7 (GND), U2.8 (GND), U3.3 (GND), U4.2 (VSS)
unnamed: AE1.1 (A), C8.2, C9.2
unnamed: C7.2, C8.1, U1.2 (LNA_IN)
unnamed: D1.4 (DIN), Q1.3 (C), R10.1
unnamed: J3.A5 (CC1), R6.2
unnamed: J3.B5 (CC2), R7.2
unnamed: JP1.2 (B), R12.1, U2.3 (SDO/SAO)
unnamed: JP2.2 (B), R9.1, U3.2 (ADDR)
unnamed: Q1.1 (B), R4.1
unnamed: R3.2, U3.5 (DVI)

Notes on the sheet:
环境光传感器
I2C上拉
加速度计
LDO
LCD 和 SD 使用不同的SPI Bus
留个位置免得麻烦
should it have esd?
记得检查各个I2C地址

Board: 4 copper layers, 30.0 x 29.0 mm, 37 parts (8 on the bottom side), 31 nets.

## Commit log

2022-05-07 Init Repo
2022-05-07 Place Parts
2022-05-07 Random Version 0.0
2022-05-08 Improve According to t123yh
2022-05-08 Improve again
2022-05-08 V0.1
2022-05-08 V0.1 FinalVer
2022-05-08 ScreenBoardV0
2022-05-13 Fix Error
2022-05-13 只用三轴还是不方便输入，考虑增加波轮
2022-05-15 Fix Error & add SW
2022-05-15 投板版本
2022-05-15 修正开窗问题
2022-05-21 V0.2 Arrived
2022-06-14 新款拨轮
2022-06-17 Fix most 3D parts
